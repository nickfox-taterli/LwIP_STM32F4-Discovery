# Keil uVision project LwIP_STM32F4.uvprojx, settings and files
target LwIP_HTTP_UDPTCP_RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: LwIP_HTTP_UDPTCP_RTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Middlewares/Third_Party/cJSON/Include;../Middlewares/Third_Party/WebClient;../Drivers/CMSIS/Include;../Demo/Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_utils.c stm32f4xx_ll_rcc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_exti.c stm32f4xx_ll_eth.c stm32f4xx_ll_rng.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c list.c timers.c croutine.c tasks.c stream_buffer.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c lwip.c stm32f4xx_it.c ethernetif.c
  group Application/Demo
    ../Demo/Src/: web_view.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c autoip.c ip4_frag.c ip4.c igmp.c dhcp.c etharp.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6.c ip6_addr.c icmp6.c ip6_frag.c mld6.c dhcp6.c ethip6.c inet6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: eap.c ppp.c chap-md5.c magic.c chap_ms.c utils.c pppol2tp.c pppcrypt.c ipcp.c ipv6cp.c fsm.c multilink.c pppoe.c demand.c eui64.c auth.c upap.c lcp.c mppe.c vj.c ecp.c pppos.c chap-new.c pppapi.c ccp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/core/: udp.c dns.c def.c raw.c tcp_in.c inet_chksum.c tcp.c ip.c sys.c stats.c pbuf.c init.c netif.c memp.c timeouts.c mem.c tcp_out.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c netdb.c err.c tcpip.c netifapi.c api_lib.c api_msg.c sockets.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/cJSON
    ../Middlewares/Third_Party/cJSON/Source/: cJSON.c cJSON_Utils.c
  group Middlewares/WebClient
    ../Middlewares/Third_Party/WebClient/: webclient.c
software components: CMSIS:CORE 4.1.0
